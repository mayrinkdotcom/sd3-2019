<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Proj02 - Relógio 3.0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


